# IAR project Backup of cyclingSensor.ewp, settings and files
configuration CC2540DK-MINI Keyfob (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\CSC\CC254x; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_KEY=TRUE; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCOptLevel: 3
configuration CC2540F128DK-MINI Keyfob (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F128 CC2540F128
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540f128b.xcl
configuration CC2540F128 (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F128 CC2540F128
  ICC8051.CCDefines: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540f128b.xcl
  group APP
    ../Source/: cyclingSensor.c cyclingSensor.h cyclingSensor_Main.c OSAL_cyclingSensor.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/CSC/CC254x/: cyclingservice.c cyclingservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/Roles/CC254x/: peripheral.c peripheral.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
